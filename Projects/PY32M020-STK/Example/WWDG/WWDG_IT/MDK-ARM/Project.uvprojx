# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32M020x6 Puya
  pack: Puya.PY32Mxxx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32M020x6
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\PY32M0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\PY32M020xx_Start_Kit;..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\PY32M0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Common
    ./: startup_py32m020xx.s
    ../Src/: system_py32m0xx.c
  group Application/User
    ../Src/: main.c py32m0xx_hal_msp.c py32m0xx_it.c
  group BSP/py32m020xx_Start_Kit
    ../../../../../../drivers/BSP/PY32M020xx_Start_Kit/: py32m020xx_Start_Kit.c
  group Drivers/PY32M0xx_HAL_Driver
    ../../../../../../Drivers/PY32M0xx_HAL_Driver/Src/: py32m0xx_hal.c
    ../../../../../../drivers/PY32M0xx_HAL_Driver/src/: py32m0xx_hal_rcc.c py32m0xx_hal_rcc_ex.c py32m0xx_hal_flash.c py32m0xx_hal_gpio.c py32m0xx_hal_wwdg.c py32m0xx_hal_tim.c py32m0xx_hal_tim_ex.c py32m0xx_hal_dma.c py32m0xx_hal_pwr.c py32m0xx_hal_uart.c py32m0xx_hal_cortex.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
