# Keil uVision project Project.uvprojx, settings and files
target PY32M020x6_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32M020x6 Puya
  pack: Puya.PY32Mxxx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Target +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32M020x6
  c include: ..\Inc;..\..\..\Drivers\PY32M0xx_HAL_Driver\Inc;..\..\..\Drivers\CMSIS\Device\PY32M0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Common
    ../Src/: system_py32m0xx.c
    ./: startup_py32m020xx.s
  group Application/User
    ../Src/: main.c py32m0xx_it.c
  group Drivers/PY32M0xx_HAL_Driver
    ../../../Drivers/PY32M0xx_HAL_Driver/Src/: py32m0xx_ll_utils.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.6.0
